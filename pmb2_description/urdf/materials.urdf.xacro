Commit message: material Black

File: pmb2_description/urdf/materials.urdf.xacro (robot description, xacro)
@@ -32,3 +32,6 @@
     <color rgba="1.0 0.69 0.0 1.0"/>
   </material>
+  <material name="Black">
+    <color rgba="0.0 0.0 0.0 1.0"/>
+  </material>
 </robot>
